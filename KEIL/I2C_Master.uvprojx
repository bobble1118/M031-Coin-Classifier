# Keil uVision project I2C_Master.uvprojx, settings and files
target I2C_Master (6240000::V6.24::ARMCLANG)
  device: M032KG8AE Nuvoton
  pack: Nuvoton.NuMicroM0_DFP.1.0.1
  cpu: IRAM(0x20000000,0x10000) IROM(0x00000000,0x40000) IROM2(0x00100000,0x1000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: I2C_Master
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=1
  c include: ..\Inc;..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\Device\Nuvoton\M031\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x100000 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --map --first='startup_M031Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M031/Source/: system_M031Series.c
    ../../../../Library/Device/Nuvoton/M031/Source/ARM/: startup_M031Series.s
  group Library
    ../../../../Library/StdDriver/src/: retarget.c clk.c uart.c i2c.c gpio.c
  group User
    ../Src/: main.c app.c camera.c ov7670_driver.c cnn_model.c
    ../Inc/: cnn_model_weights.h cnn_api.h app.h camera.h ov7670_driver.h
